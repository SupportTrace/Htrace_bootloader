# Keil uVision project htrace_dfu.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: NRF52_HTRACE_dfu +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BLE_STACK_SUPPORT_REQD CONFIG_GPIO_AS_PINRESET DEBUG_NRF FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: ..\..\config;..\sdk\components\ble\common;..\sdk\components\boards;..\sdk\components\libraries\atomic;..\sdk\components\libraries\atomic_fifo;..\sdk\components\libraries\balloc;..\sdk\components\libraries\bootloader;..\sdk\components\libraries\bootloader\ble_dfu;..\sdk\components\libraries\bootloader\dfu;..\sdk\components\libraries\crc32;..\sdk\components\libraries\crypto;..\sdk\components\libraries\crypto\backend\cc310;..\sdk\components\libraries\crypto\backend\cc310_bl;..\sdk\components\libraries\crypto\backend\cifra;..\sdk\components\libraries\crypto\backend\mbedtls;..\sdk\components\libraries\crypto\backend\micro_ecc;..\sdk\components\libraries\crypto\backend\nrf_hw;..\sdk\components\libraries\crypto\backend\nrf_sw;..\sdk\components\libraries\crypto\backend\oberon;..\sdk\components\libraries\delay;..\sdk\components\libraries\experimental_section_vars;..\sdk\components\libraries\fstorage;..\sdk\components\libraries\log;..\sdk\components\libraries\log\src;..\sdk\components\libraries\mem_manager;..\sdk\components\libraries\memobj;..\sdk\components\libraries\queue;..\sdk\components\libraries\ringbuf;..\sdk\components\libraries\scheduler;..\sdk\components\libraries\sha256;..\sdk\components\libraries\stack_info;..\sdk\components\libraries\strerror;..\sdk\components\libraries\svc;..\sdk\components\libraries\util;..\sdk\components\softdevice\common;..\sdk\components\softdevice\s132\headers;..\sdk\components\softdevice\s132\headers\nrf52;..\..;..\sdk\external\fprintf;..\sdk\external\micro-ecc\micro-ecc;..\sdk\external\nano-pb;..\sdk\external\nrf_oberon;..\sdk\external\nrf_oberon\include;..\sdk\external\segger_rtt;..\sdk\integration\nrfx;..\sdk\modules\nrfx;..\sdk\modules\nrfx\hal;..\sdk\modules\nrfx\mdk;.\config;.\
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEBUG_NRF FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG_NRF,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_DEBUG_VERSION,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: ..\..\config;..\sdk\components\ble\common;..\sdk\components\boards;..\sdk\components\libraries\atomic;..\sdk\components\libraries\atomic_fifo;..\sdk\components\libraries\balloc;..\sdk\components\libraries\bootloader;..\sdk\components\libraries\bootloader\ble_dfu;..\sdk\components\libraries\bootloader\dfu;..\sdk\components\libraries\crc32;..\sdk\components\libraries\crypto;..\sdk\components\libraries\crypto\backend\cc310;..\sdk\components\libraries\crypto\backend\cc310_bl;..\sdk\components\libraries\crypto\backend\cifra;..\sdk\components\libraries\crypto\backend\mbedtls;..\sdk\components\libraries\crypto\backend\micro_ecc;..\sdk\components\libraries\crypto\backend\nrf_hw;..\sdk\components\libraries\crypto\backend\nrf_sw;..\sdk\components\libraries\crypto\backend\oberon;..\sdk\components\libraries\delay;..\sdk\components\libraries\experimental_section_vars;..\sdk\components\libraries\fstorage;..\sdk\components\libraries\log;..\sdk\components\libraries\log\src;..\sdk\components\libraries\mem_manager;..\sdk\components\libraries\memobj;..\sdk\components\libraries\queue;..\sdk\components\libraries\ringbuf;..\sdk\components\libraries\scheduler;..\sdk\components\libraries\sha256;..\sdk\components\libraries\stack_info;..\sdk\components\libraries\strerror;..\sdk\components\libraries\svc;..\sdk\components\libraries\util;..\sdk\components\softdevice\common;..\sdk\components\softdevice\s132\headers;..\sdk\components\softdevice\s132\headers\nrf52;..\..;..\sdk\external\fprintf;..\sdk\external\micro-ecc\micro-ecc;..\sdk\external\nano-pb;..\sdk\external\nrf_oberon;..\sdk\external\nrf_oberon\include;..\sdk\external\segger_rtt;..\sdk\integration\nrfx;..\sdk\modules\nrfx;..\sdk\modules\nrfx\hal;..\sdk\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x72000 size 0xc000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
    ../sdk/: pk.c
  group Board Definition
    ./: htrace_board.h
  group nRF_BLE
    ../sdk/components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../sdk/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../sdk/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../sdk/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ../sdk/components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../sdk/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../sdk/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../sdk/components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../sdk/modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../sdk/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../sdk/components/libraries/scheduler/: app_scheduler.c
    ../sdk/components/libraries/crc32/: crc32.c
    ../sdk/components/libraries/mem_manager/: mem_manager.c
    ../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../sdk/components/libraries/atomic/: nrf_atomic.c
    ../sdk/components/libraries/balloc/: nrf_balloc.c
    ../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../sdk/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../sdk/components/libraries/memobj/: nrf_memobj.c
    ../sdk/components/libraries/queue/: nrf_queue.c
    ../sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ../sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../sdk/components/libraries/strerror/: nrf_strerror.c
    ../sdk/components/libraries/sha256/: sha256.c
  group nRF_Log
    ../sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../sdk/external/nrf_oberon/lib/nrf52/: oberon_short_wchar_2.0.5.lib
  group nRF_SVC
    ../sdk/components/libraries/bootloader/dfu/: nrf_dfu_svci_handler.c
    ../sdk/components/libraries/svc/: nrf_svc_handler.c
  group nRF_Segger_RTT
    ../sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../sdk/external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../sdk/external/nano-pb/: pb_common.c pb_decode.c
target flash_s132_nrf52_6.1.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\config;..\config
  asm define: __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0
  asm include: ..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x72000 size 0xc000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
target setting_merged (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: wise_dfu_settings.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEBUG_NRF FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x72000 size 0xc000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.1.2, Device:Startup 8.17.0
